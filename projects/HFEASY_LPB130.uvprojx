# Keil uVision project HFEASY_LPB130.uvprojx, settings and files
target LPB130 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") CLOCK(12000000) ESEL ELITTLE
  output: HFEASY
  AfterMake: $K/gcc-arm-none-eabi-5_4-2016q3-20160926-win32/bin/arm-none-eabi-objcopy -O binary ./build_lpxx30/HFEASY.elf ./build_lpxx30/HFEASY.bin
  AfterMake: ../tools/gen_upgrade_bin.exe LPB230 lzma  ../tools/bootloader_lpb130.bin ./build_lpxx30/HFEASY.bin ./build_lpxx30/HFEASY_IMAGE.bin ./build_lpxx30/HFEASY_UPGRADE.bin
  group src
    ../src/: app_main.c buzzer.c config.c dimmer.c gpio.c httpd.c i2c.c led.c mqttcli.c mqttlib.c relay.c timer.c network.c
    ../sdk/4.13/libs/: startup_LPBX3GCC.S
