# Keil uVision project HFEASY.uvproj, settings and files
target MODULE (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: HFEASY_MODULE +hex
  AfterMake: fromelf.exe --bin --output ./output/HFEASY.bin ./output/HFEASY.axf
  AfterMake: ../tools/gen_upgrade_bin.exe ./output/HFEASY.bin ./output/HFEASY_MODULE_UPGRADE.bin
  c flags: OneElfS=1 v6Lang=1 v6LangP=1
  c define: __KEIL_MDK__ __LPT100F__ __HFEASY_MODULE__
  c misc: --diag_suppress=494  --c99
  c include: ..\sdk\1.52\include
  scatter file: LPBS2W.sct
  link misc: --keep *.o(.mach*.init)  --keep *.o(.shell*.cmd)  --keep *.o(.sched.stub*) --keep *.o(.driver*.isr)
  group src
    ../src/: mqttlib.c startup.c app_main.c httpd.c config.c mqttcli.c gpio.c buzzer.c timer.c
  group libs
    ../sdk/1.52/libs/: LPB100Kernel.lib
target PLUG (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: HFEASY_PLUG +hex
  AfterMake: fromelf.exe --bin --output ./output/HFEASY_PLUG.bin ./output/HFEASY_PLUG.axf
  AfterMake: ../tools/gen_upgrade_bin.exe ./output/HFEASY_PLUG.bin ./output/HFEASY_PLUG_UPGRADE.bin
  c flags: OneElfS=1 v6Lang=1 v6LangP=1
  c define: __KEIL_MDK__ __LPB100__ __HFEASY_PLUG__
  c misc: --diag_suppress=494  --c99
  c include: ..\sdk\1.52\include
  scatter file: LPBS2W.sct
  link misc: as above
target DIMMER (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: HFEASY_DIMMER +hex
  AfterMake: fromelf.exe --bin --output ./output/HFEASY_DIMMER.bin ./output/HFEASY_DIMMER.axf
  AfterMake: ../tools/gen_upgrade_bin.exe ./output/HFEASY_DIMMER.bin ./output/HFEASY_DIMMER_UPGRADE.bin
  c flags: OneElfS=1 v6Lang=1 v6LangP=1
  c define: __KEIL_MDK__ __LPB100__ __HFEASY_DIMMER__
  c misc: --diag_suppress=494  --c99
  c include: ..\sdk\1.52\include
  scatter file: LPBS2W.sct
  link misc: as above
